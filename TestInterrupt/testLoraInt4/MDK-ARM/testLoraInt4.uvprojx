# Keil uVision project testLoraInt4.uvprojx, settings and files
target testLoraInt4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: testLoraInt4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx, USE_STM32L4XX_NUCLEO,REGION_AS923
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../BSP/Components/sx1276;../BSP/Components/hts221;../BSP/Components/lps25hb;../BSP/Components/lps22hb;../BSP/X_NUCLEO_IKS01A2;../BSP/SX1276MB1MAS;../BSP/STM32L4xx_Nucleo;../Middlewares/Third_Party/LoRaWAN/Patterns/Basic;../Middlewares/Third_Party/LoRaWAN/Mac;../Middlewares/Third_Party/LoRaWAN/Mac/Region;../Middlewares/Third_Party/LoRaWAN/Utilities;../Middlewares/Third_Party/LoRaWAN/Crypto;../LoRaWAN/App/inc;../BSP/Components/Common;../Middlewares/Third_Party/LoRaWAN/Phy;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/BSP/Components
    ../BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../BSP/Components/sx1276/: sx1276.c
  group Application/User
    ../Src/: main.c gpio.c sys.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hw.c
    ../LoRaWAN/App/src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c vcom.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Driver/BSP/X_NUCLEO_IKS01A2
    ../../../Github/Hardware/STM32CubeExpansion_LRWAN_V1.3.1/Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Driver/BSP/sx1276mb1mas
    ../../../Github/Hardware/STM32CubeExpansion_LRWAN_V1.3.1/Drivers/BSP/SX1276MB1MAS/: sx1276mb1mas.c
  group Middlewares/LoRaWAN/Patterns/Basic
    ../../../Github/Hardware/STM32CubeExpansion_LRWAN_V1.3.1/Middlewares/Third_Party/LoRaWAN/Patterns/Basic/: lora.c lora-test.c
  group Middlewares/LoRaWAN/Mac
    ../../../Github/Hardware/STM32CubeExpansion_LRWAN_V1.3.1/Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Middlewares/LoRaWAN/MAC/Region
    ../../../Github/Hardware/STM32CubeExpansion_LRWAN_V1.3.1/Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Middlewares/LoRaWAN/Utilities
    ../../../Github/Hardware/STM32CubeExpansion_LRWAN_V1.3.1/Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c queue.c systime.c timeServer.c trace.c utilities.c
  group Middlewares/LoRaWAN/Crypto
    ../../../Github/Hardware/STM32CubeExpansion_LRWAN_V1.3.1/Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
software components: CMSIS:CORE 4.3.0
